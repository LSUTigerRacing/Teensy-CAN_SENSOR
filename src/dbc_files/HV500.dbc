VERSION ""

NS_ :
    NS_DESC_
	CM_
	BA_DEF_
	BA_
	VAL_
	CAT_DEF_
	CAT_
	FILTER
	BA_DEF_DEF_
	EV_DATA_
	ENVVAR_DATA_
	SGTYPE_
	SGTYPE_VAL_
	BA_DEF_SGTYPE_
	BA_SGTYPE_
	SIG_TYPE_REF_
	VAL_TABLE_
	SIG_GROUP_
	SIG_VALTYPE_
	SIGTYPE_VALTYPE_
	BO_TX_BU_
	BA_DEF_REL_
	BA_REL_
	BA_DEF_DEF_REL_
	BU_SG_REL_
	BU_EV_REL_
	BU_BO_REL_
	SG_MUL_VAL_

BS_:

BU_:

BO_ 23 General_Data1: 8 Motor_CNTRL
    SG_ DUTY_CYCLE : 31|16@1+ (1,0) [-3276,3276] "%" Dash
    SG_ MC_INPUT_V : 47|16@1+ (1,0) [-3276,3276] "V" Dash

BO_ 279 General_Data2: 8 Motor_CNTRL
    SG_ AC_Current : 0|16@1+ (1,0) [-3276,3276] "" Dash
    SG_ DC_Current : 16|16@1+ (1,0) [-3276,3276] "" Dash

BO_ 535 General_Data3: 8 Motor_CNTRL
    SG_ MC_Temp : 0|16@1+ (1,0) [-3276,3276] "�C" Dash
    SG_ Motor_Temp : 16|16@1+ (1,0) [-3276,3276] "�C" Dash
    SG_ Fault_Code : 32|8@1+ (1,0) [0,255] "" Dash

BO_ 791 General_Data4: 8 Motor_CNTRL
    SG_ FOC_id : 0|32@1+ (1,0) [-21474836,21474836] "" Dash
    SG_ FOC_iq : 32|32@1+ (1,0) [-21474836,21474836] "" Dash

BO_ 1047 General_Data5: 8 Motor_CNTRL
    SG_ MC_Throttle : 0|8@1+ (1,0) [-128,128] "" Dash
    SG_ Brake : 8|16@1+ (1,0) [-128,128] "" Dash
